## block_dev/test_module/Kconfig
```kconfig
config VBLOCK
    tristate "Test driver"
    help
        This is a demo for test
```
